# Keil uVision project F103Cx_FreeRTOS_emptyPrj.uvprojx, settings and files
target F103Cx_FreeRTOS_emptyPrj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103Cx_FreeRTOS_emptyPrj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS;..\..\stdLib\inc;..\..\user;..\..\system\delay;..\..\system\sys;..\..\system\usart;..\..\peripheral\LED;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\peripheral\uart1;..\..\peripheral\uart2;..\..\peripheral\uart3;..\..\APP\onenet_http;..\..\system\structure;..\..\peripheral\timer3;..\..\peripheral\wifi;..\..\peripheral\spi1;..\..\peripheral\oled;..\..\APP\seniverse_http;..\..\APP\net_time;..\..\APP\oled_ui
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../../CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../CMSIS/: core_cm3.c system_stm32f10x.c
  group stdLib
    ../../stdLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../../user/: main.c stm32f10x_it.c
  group system
    ../../system/delay/: delay.c
    ../../system/sys/: sys.c
    ../../system/usart/: usart.c
    ../../system/structure/: structure.c
  group peripheral
    ../../peripheral/LED/: led.c
    ../../peripheral/uart1/: uart1.c
    ../../peripheral/uart2/: uart2.c
    ../../peripheral/uart3/: uart3.c
    ../../peripheral/timer3/: timer3.c
    ../../peripheral/wifi/: wifi.c
    ../../peripheral/spi1/: spi1.c
    ../../peripheral/oled/: oled.c
  group FreeRTOS_core
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_portable
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group APP
    ../../APP/onenet_http/: onenet_http.c
    ../../APP/seniverse_http/: seniverse_http.c
    ../../APP/net_time/: net_time.c
    ../../APP/oled_ui/: oled_ui.c
